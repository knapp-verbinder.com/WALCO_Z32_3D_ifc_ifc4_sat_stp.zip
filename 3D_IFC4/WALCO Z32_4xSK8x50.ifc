Properties of the parts of a building model (IFC4)

# File
Description: Unknown
File name: WALCO Z32_4xSK8x50
Time: 2022-03-02T11:02:20+01:00
Author: Unknown
Organization: Unknown
Written by: ST-DEVELOPER v16.7
Made in: Unknown
Authorization: OpenTools
Comment: Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: OPTION: strings as raw bytes, not using required /X/ escapes
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcSite, Default Site
RefElevation: 0 mm

# IfcBuilding, Default Building
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingStorey, Default Building Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Walco_32_1 (2)
In: Default Building Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Z531_SK_Schraube_8x50_ohne CUT (4)
In: Default Building Storey
PredefinedType: ELEMENT
